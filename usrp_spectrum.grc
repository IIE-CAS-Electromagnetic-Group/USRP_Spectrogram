options:
  parameters:
    generate_options: qt_gui
    id: usrp_spectrum
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: filesave_button
  id: variable_qtgui_push_button
  parameters:
    label: filesave_button
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: freq
    orient: Qt.Horizontal
    start: '400000000'
    step: '10000000'
    stop: '4400000000'
    value: '2415000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '31.5'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '30000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: iq_data.bin
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: filesave_button
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_addr: name:u220v2
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_selector_0, '0', blocks_null_sink_0, '0']
- [blocks_selector_0, '1', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_selector_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
